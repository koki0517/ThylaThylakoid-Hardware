# Repository koki0517/ThylaThylakoid-Hardware

File README.md:

# ThylaThylakoid-Hardware

[CADデータ](https://a360.co/4eEsM2K)(Autodesk Fusion)

## KiCad design 電源基板/電源基板.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 1000u; CP_Radial_D8.0mm_P3.50mm
D1, D2: D_Shockley; D_DO-201AD_P12.70mm_Horizontal
D3: RED; LED_D5.0mm_Horizontal_O3.81mm_Z3.0mm
F1: 10A; 3557-15_KEY
FAN1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J1: XT30; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J3: Power Switch; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: PWR OUT; JST_VH_B5P-VH_1x05_P3.96mm_Vertical
LT8640-1, LT8640-2, LT8640-3: LT8640
MES1: Voltmeter_DC_XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q2: Q_NMOS_GDS; TO-220-3_Vertical
R1: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: ATtiny85-20P; DIP-8_W7.62mm
U2: NJM12888F33-TE1; PI-SOT-23-5-E-A_NMD

Connections:
+5V: D2.2 (A), J4.2, LT8640-3.11 (Vout), LT8640-3.12 (Vout), LT8640-3.13 (Vout)
+5VA: C2.1, U1.8 (VCC), U2.5 (VOUT)
/6VA: J4.5, LT8640-1.11 (Vout), LT8640-1.12 (Vout), LT8640-1.13 (Vout)
/6VB: J4.4, LT8640-2.11 (Vout), LT8640-2.12 (Vout), LT8640-2.13 (Vout)
/init_5v: LT8640-3.4 (EN/UV), U1.2 (XTAL1/PB3)
/init_6v: LT8640-1.4 (EN/UV), LT8640-2.4 (EN/UV), U1.5 (AREF/PB0)
/led: D3.2 (A), U1.6 (PB1)
/tx: J2.2, U1.3 (XTAL2/PB4)
GND: C1.2, C2.2, J2.1, LT8640-1.8 (GND), LT8640-1.9 (GND), LT8640-1.10 (GND), LT8640-2.8 (GND), LT8640-2.9 (GND), LT8640-2.10 (GND), LT8640-3.8 (GND), LT8640-3.9 (GND), LT8640-3.10 (GND), Q2.2 (D), R1.2, R3.2, U1.4 (GND), U2.2 (GND)
GND1: J4.3, LT8640-1.14 (GND), LT8640-1.15 (GND), LT8640-1.16 (GND), LT8640-2.14 (GND), LT8640-2.15 (GND), LT8640-2.16 (GND)
GND2: FAN1.1
GND3: J4.1, LT8640-3.14 (GND), LT8640-3.15 (GND), LT8640-3.16 (GND)
unnamed: C3.2, D1.2 (A), J1.1, MES1.1 (-), Q2.3 (S), R5.2
unnamed: D3.1 (K), R1.1
unnamed: F1.1, F1.2, J1.2
unnamed: J3.1, Q2.1 (G), R5.1
unnamed: R2.2, R3.1, U1.7 (PB2)
VDD: C1.1, C3.1, D1.1 (K), D2.1 (K), F1.3, F1.4, FAN1.2, J3.2, LT8640-1.1 (Vin), LT8640-1.2 (Vin), LT8640-1.3 (Vin), LT8640-2.1 (Vin), LT8640-2.2 (Vin), LT8640-2.3 (Vin), LT8640-3.1 (Vin), LT8640-3.2 (Vin), LT8640-3.3 (Vin), MES1.2 (+), R2.1, U2.1 (VIN)

Notes on the sheet:
DCDC 6V 駆動系
電圧管理
外部出力
電源入力+ロードスイッチ
冷却ファン
DCDC 5V ロジック系
ATtiny用5V

Board: 2 copper layers, 59.7 x 49.5 mm, 23 parts (0 on the bottom side), 17 nets.

File 電源基板/jlcpcb/production_files/BOM-電源基板.csv:

Comment,Designator,Footprint,LCSC
PWR OUT,J4,JST_VH_B5P-VH_1x05_P3.96mm_Vertical,
220,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
R_Small,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
XT30,J1,AMASS_XT30U-M_1x02_P5.0mm_Vertical,
Q_NMOS_GDS,Q2,TO-220-3_Vertical,
ATtiny85-20P,U1,DIP-8_W7.62mm,
Voltmeter_DC_XH,MES1,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,
3557-15,F1,3557-15_KEY,
Power Switch,J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,
Conn_01x02_Pin,J2,PinHeader_1x02_P2.54mm_Vertical,
R_Small,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
1k,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
~,LT8640-1,LT8640,
1000u,C3,CP_Radial_D8.0mm_P3.50mm,
D_Shockley,D1,D_DO-201AD_P12.70mm_Horizontal,
RED,D3,LED_D5.0mm_Horizontal_O3.81mm_Z3.0mm,
Conn_01x02_Pin,FAN1,PinHeader_1x02_P2.54mm_Vertical,
~,LT8640-2,LT8640,
~,LT8640-3,LT8640,

## KiCad design サーボ基板/サーボ基板.kicad_pcb

Parts:
C1: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C9, C10: 100u; CP_Radial_D6.3mm_P2.50mm
C4, C5, C7, C8: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C12, C13, C14: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 0.33uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: RED LED; LED_D5.0mm
FB1, FB2, FB3, FB4: 100R; L_Walsin_WLFM201209x
Gyro1: BNO055
J1, J15, J16, J17: Conn_01x03; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J2: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J4: PWR OUT; JST_VH_B5PS-VH_1x05_P3.96mm_Horizontal
J7, J8: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J9: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J19: Power Switch; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
LDO1: TO-252-2
Line1: Conn_02x10; PinHeader_2x10_P2.54mm_Vertical
Q1: Q_NMOS_GDS; TO-252-2
R3, R4, R7: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_Push; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SubBoard1: Conn_02x10; PinHeader_2x10_P2.54mm_Vertical
ToF1, ToF2: GY530
U2: DEV-16771; MODULE_DEV-16771; PARTREV 4.1
U5, U6: ADuM121N; SOP-8_DIP
U7: SN74HC241DW; CERDIP-20_W7.62mm_SideBrazed_Socket
VisionAI1: Grove Vision AI V2

Connections:
+3.3V: FB2.2, SW1.1, SW2.1, U2.3.3V_2 (3.3V)
+5V: C1.2, FB3.1, LDO1.3 (Vout), R7.2, R8.1, U7.20 (VCC)
+5VA: FB1.1, FB4.1, Gyro1.1 (VIN), J4.4, J7.2, J8.2, J9.1, J19.2, Line1.1, SubBoard1.1, ToF1.1 (VIN), ToF2.1 (VIN), VisionAI1.14 (5V)
/6VA: C9.1, C11.2, C12.2, C15.1, J1.2, J4.1, J15.2, LDO1.1 (Vin)
/6VB: C10.1, C13.2, C14.2, J4.2, J16.2, J17.2
/LiDAR_PWM: J2.2, U2.10 (CS1)
/LiDAR_TX: J2.1, U2.25 (A11)
/LimSW1: R3.1, SW1.2, U2.2 (OUT2)
/LimSW2: R4.1, SW2.2, U2.3 (LRCLK2)
/LimSW3: SubBoard1.17, U2.32 (OUT1B)
/LimSW4: SubBoard1.18, U2.31 (CTX3)
/Line1: Line1.9, U2.40 (A16)
/Line2: Line1.10, U2.38 (A14)
/Line3: Line1.20, U2.27 (A13)
/Line4: Line1.19, U2.39 (A15)
/Line5: Line1.18, U2.41 (A17)
/Line6: Line1.17, U2.14 (A0)
/Line7: Line1.16, U2.15 (A1)
/Line8: Line1.15, U2.20 (A6)
/Line9: Line1.14, U2.21 (A7)
/Line10: Line1.13, U2.22 (A8)
/Line11: Line1.12, U2.23 (A9)
/PWM5: J7.3, SubBoard1.19
/PWM6: J8.3, SubBoard1.20
/loadcell1: SubBoard1.8, U2.24 (A10)
/loadcell2: SubBoard1.4, U2.26 (A12)
/rx2_main: J9.3, U2.7 (RX2)
/rx7_main: U2.0 (RX1), VisionAI1.8 (TXD)
/rx8_main: SubBoard1.7, U2.28 (RX7)
/rx_dxl: U2.34 (RX8), U6.2 (VOA)
/scl: Gyro1.4 (SCL), Line1.4, SubBoard1.5, ToF1.3 (SCL), ToF2.3 (SCL), U2.19 (A5)
/scl1: Line1.6, U2.16 (A2)
/sda: Gyro1.3 (SDA), Line1.3, SubBoard1.3, ToF1.4 (SDA), ToF2.4 (SDA), U2.18 (A4)
/sda1: Line1.5, U2.17 (A3)
/tx: J3.2, SubBoard1.11
/tx2_main: J9.4, U2.8 (TX2)
/tx7_main: U2.1 (TX1), VisionAI1.7 (RXD)
/tx8_main: SubBoard1.9, U2.29 (TX7)
/tx_dxl: U2.35 (TX8), U6.3 (VIB)
/tx_en: U2.36 (CS2), U5.3 (VIB)
/xshut1: Line1.7, U2.4 (BCLK2)
/xshut2: Line1.8, U2.9 (OUT1C)
/xshut3: ToF1.5 (XSHUT), U2.5 (IN2)
/xshut4: ToF2.5 (XSHUT), U2.6 (OUT1D)
/xshut5: SubBoard1.16, U2.30 (CRX3)
/xshut6: SubBoard1.15, U2.12 (MISO)
/xshut7: SubBoard1.14, U2.11 (MOSI)
/xshut8: SubBoard1.13, U2.33 (MCLK2)
DATA: J1.3, J15.3, J16.3, J17.3, R7.1, U7.2 (1A1), U7.3 (2Y4)
GND: C1.1, C7.2, C8.1, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.2, D1.1 (K), J1.1, J4.3, J15.1, J16.1, J17.1, LDO1.2 (GND), U5.5 (GND2), U6.5 (GND2), U7.10 (GND)
GND2: C2.2, C4.2, C5.2, Gyro1.2 (GND), Gyro1.7 (GND), J2.3, J3.1, J7.1, J8.1, J9.2, Line1.2, Line1.11, Q1.2 (D), R3.2, R4.2, SubBoard1.2, SubBoard1.6, SubBoard1.10, SubBoard1.12, ToF1.2 (GND), ToF2.2 (GND), U2.GND1 (GND), U2.GND2 (GND), U2.GND3 (GND), U5.4 (GND1), U6.4 (GND1), VisionAI1.13 (GND)
unnamed: C2.1, FB1.2, U2.VIN
unnamed: D1.2 (A), R8.2
unnamed: J4.5, Q1.3 (S), R9.2
unnamed: J19.1, Q1.1 (G), R9.1
unnamed: C4.1, C5.1, FB2.1, U5.1 (VDD1), U6.1 (VDD1)
unnamed: C7.1, C8.2, FB3.2, U5.8 (VDD2), U6.8 (VDD2)
unnamed: U5.6 (VOB), U7.1 (*1OE), U7.19 (2OE)
unnamed: U6.7 (VIA), U7.18 (1Y1)
unnamed: U6.6 (VOB), U7.17 (2A4)

Notes on the sheet:
XL330-M288-T
側面ToF
シリアル変換+アイソレート
電源入力
電源基板ATtiny
ジャイロ
ライン基板
リミットスイッチ
Teensy4.1
サブ基板
カメラ
LiDAR
Servo

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
Board: 2 copper layers, 99.8 x 96.1 mm, 48 parts (6 on the bottom side), 60 nets.

File サーボ基板/jlcpcb/production_files/BOM-サーボ基板.csv:

Comment,Designator,Footprint,LCSC
Conn_01x02_Pin,J3,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,
0.01u,C8,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
0.01u,C4,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
2.2u,C1,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
100u,C2,CP_Radial_D6.3mm_P2.50mm,
100u,C10,CP_Radial_D6.3mm_P2.50mm,
10k,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
RED LED,D1,LED_D5.0mm,
PWR OUT,J4,JST_VH_B5PS-VH_1x05_P3.96mm_Horizontal,
Conn_01x04_Pin,J2,PinHeader_1x04_P2.54mm_Vertical,
0.01u,C5,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
Conn_01x03,J1,JST_EH_S3B-EH_1x03_P2.50mm_Horizontal,
~,LDO1,TO-252-2,
DEV-16771,U2,MODULE_DEV-16771,
100R,FB2,L_Walsin_WLFM201209x,
Power Switch,J19,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,
10k,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
SW_Push,SW1,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,
Conn_01x03,J16,JST_EH_S3B-EH_1x03_P2.50mm_Horizontal,
0.01u,C7,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
Conn_01x03,J15,JST_EH_S3B-EH_1x03_P2.50mm_Horizontal,
10k,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
0.1u,C13,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
~,ToF2,GY530,
100R,FB1,L_Walsin_WLFM201209x,
220,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
SW_Push,SW2,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,
100u,C9,CP_Radial_D6.3mm_P2.50mm,
0.1u,C12,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
0.1u,C11,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
0.33uF,C15,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
~,ToF1,GY530,
ADuM121N,U5,SOP-8_DIP,
1k,R9,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
Conn_01x04,J9,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,
0.1u,C14,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
Conn_01x03,J17,JST_EH_S3B-EH_1x03_P2.50mm_Horizontal,
~,Gyro1,BNO055,
100R,FB3,L_Walsin_WLFM201209x,
Conn_02x10,Line1,PinHeader_2x10_P2.54mm_Vertical,
~,VisionAI1,Grove Vision AI V2,
SN74HC241DW,U7,CERDIP-20_W7.62mm_SideBrazed_Socket,
ADuM121N,U6,SOP-8_DIP,
Q_NMOS_GDS,Q1,TO-252-2,
100R,FB4,L_Walsin_WLFM201209x,
Conn_02x10,SubBoard1,PinHeader_2x10_P2.54mm_Vertical,
Conn_01x03_Pin,J7,PinHeader_1x03_P2.54mm_Vertical,
Conn_01x03_Pin,J8,PinHeader_1x03_P2.54mm_Vertical,

## KiCad design ライン基板/ライン基板.kicad_pcb

Board: 2 copper layers, 99.6 x 77.0 mm, 51 parts (13 on the bottom side), 43 nets.

Parts:
A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11: RPR-220; PHODET_RPR-220
C1: 47u; CP_Radial_D5.0mm_P2.00mm
C2: 0.33u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
ENC1: EC12PLRGBSDVBF
FB1: 100R; L_Walsin_WLFM201209x
J1: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
J1#2: Conn_02x10; PinHeader_2x10_P2.54mm_Vertical
J2: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J2#2: Conn_01x06; PinSocket_2x03_P2.54mm_Vertical
J3: ColorSensor; PinSocket_2x04_P2.54mm_Vertical
J4: ColorSensor; PinHeader_2x04_P2.54mm_Vertical
J5: Conn_01x06; PinHeader_2x03_P2.54mm_Vertical
LDO1: PQ3RD23; TO-220-4_Vertical
R1, R2: 160; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R6, R8, R10, R12, R14, R16, R18, R20, R22, R24: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R7, R9, R11, R13, R15, R17, R19, R21, R23: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
ToF1, ToF2: VL6180X
color1, color2: TCS34725

Connections:
+3.3V: A1.4, A2.4, A3.4, A4.4, A5.4, A6.4, A7.4, A8.4, A9.4, A10.4, A11.4, C1.1, J2#2.1, J3.1, LDO1.2 (VOUT)
+3.3VA: J4.1, J5.1, ToF1.5 (VDD), ToF2.5 (VDD), color1.4 (VDD), color1.8 (LED-A), color2.4 (VDD), color2.8 (LED-A)
+5V: A1.1, A2.1, A3.1, A4.1, A5.1, A6.1, A7.1, A8.1, A9.1, A10.1, A11.1, C2.1, FB1.2, LDO1.1 (VIN)
/Line1: A1.3, J1#2.9, R3.1
/Line2: A2.3, J1#2.10, R6.1
/Line3: A3.3, J1#2.20, R8.1
/Line4: A4.3, J1#2.19, R10.1
/Line5: A5.3, J1#2.18, R12.1
/Line6: A6.3, J1#2.17, R14.1
/Line7: A7.3, J1#2.16, R16.1
/Line8: A8.3, J1#2.15, R18.1
/Line9: A9.3, J1#2.14, R20.1
/Line10: A10.3, J1#2.13, R22.1
/Line11: A11.3, J1#2.12, R24.1
/SCL: J1#2.4, J2#2.4, J3.2
/SCL1: J1#2.6, J3.7
/SCL1_: J4.7, color2.3 (SCL)
/SCL_: J4.2, J5.4, ToF1.2 (SCL), ToF2.2 (SCL), color1.3 (SCL)
/SDA: J1#2.3, J2#2.3, J3.3
/SDA1: J1#2.5, J3.6
/SDA1_: J4.6, color2.2 (SDA)
/SDA_: J4.3, J5.3, ToF1.4 (SDA), ToF2.4 (SDA), color1.2 (SDA)
/XSHUT1: J1#2.7, J2#2.5
/XSHUT1_: J5.5, ToF1.3 (GPIO0)
/XSHUT2: J1#2.8, J2#2.6
/XSHUT2_: J5.6, ToF2.3 (GPIO0)
/c1: J4.4, color1.5 (LED-C)
/c2: J4.5, color2.5 (LED-C)
GND: C1.2, C2.2, J1#2.2, J1#2.11, J2#2.2, J3.8, J4.8, J5.2, LDO1.3 (GND), R1.2, R2.2, R3.2, R4.1, R5.1, R6.2, R7.1, R8.2, R9.1, R10.2, R11.1, R12.2, R13.1, R14.2, R15.1, R16.2, R17.1, R18.2, R19.1, R20.2, R21.1, R22.2, R23.1, R24.2, ToF1.6 (GND), ToF2.6 (GND), color1.1 (GND), color2.1 (GND)
unnamed: A1.2, R4.2
unnamed: A2.2, R5.2
unnamed: A3.2, R7.2
unnamed: A4.2, R9.2
unnamed: A5.2, R11.2
unnamed: A6.2, R13.2
unnamed: A7.2, R15.2
unnamed: A8.2, R17.2
unnamed: A9.2, R19.2
unnamed: A10.2, R21.2
unnamed: A11.2, R23.2
unnamed: FB1.1, J1#2.1
unnamed: J3.4, R1.1
unnamed: J3.5, R2.1

File ライン基板/jlcpcb/production_files/BOM-ライン基板.csv:

Comment,Designator,Footprint,LCSC
ColorSensor,J4,PinHeader_2x04_P2.54mm_Vertical,
Conn_01x06,J5,PinHeader_2x03_P2.54mm_Vertical,
~,ToF1,VL6180X,
~,color2,TCS34725,
~,color1,TCS34725,
330,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R14,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R16,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R17,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
0.33u,C2,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
ColorSensor,J3,PinSocket_2x04_P2.54mm_Vertical,
330,R11,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R19,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R23,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R21,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R12,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
47u,C1,CP_Radial_D5.0mm_P2.00mm,
22k,R10,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R15,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
160,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R24,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R13,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
Conn_01x03_Pin,J2,PinHeader_1x03_P2.54mm_Vertical,
22k,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R22,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
Conn_01x05_Pin,J1,PinHeader_1x05_P2.54mm_Vertical,
100R,FB1,L_Walsin_WLFM201209x,
330,R9,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
160,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R20,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
22k,R18,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
PQ3RD23,LDO1,TO-220-4_Vertical,
22k,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
330,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
RPR-220,A9,PHODET_RPR-220,
RPR-220,A6,PHODET_RPR-220,
RPR-220,A10,PHODET_RPR-220,
RPR-220,A5,PHODET_RPR-220,
RPR-220,A8,PHODET_RPR-220,
RPR-220,A1,PHODET_RPR-220,
RPR-220,A7,PHODET_RPR-220,
RPR-220,A11,PHODET_RPR-220,
RPR-220,A2,PHODET_RPR-220,
RPR-220,A3,PHODET_RPR-220,
RPR-220,A4,PHODET_RPR-220,
~,ToF2,VL6180X,
~,ENC1,EC12PLRGBSDVBF,
